# IAR project ksurct_micromouse.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: cmsis\Include; stm32f4xx\std_periph_drivers\include; stm32f4xx\include; source\; source\control\include; source\maze\include; source\micromouse\include; source\motors\include; source\sensors\include; source\utility\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: ksurct_micromouse.srec
  ILINK.IlinkOutputFile: ksurct_micromouse.out
  ILINK.IlinkIcfFile: ksurct_micromouse.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  group source
    source/: main.cpp
  group source/control
    source/control/: pid.cpp
  group source/control/include
    source/control/include/: pid.h
  group source/maze
    source/maze/: cell.cpp maze.cpp simplefloodfill.cpp test_maze_creator.cpp weightedpathfinding.cpp
  group source/maze/include
    source/maze/include/: cell.h ipathfinder.h maze.h simplefloodfill.h test_maze_creator.h weightedpathfinding.h
  group source/micromouse
    source/micromouse/: micromouse.cpp
  group source/micromouse/include
    source/micromouse/include/: micromouse.h
  group source/motors
    source/motors/: differential_paired_stepper_motors.cpp stepper_motor.cpp
  group source/motors/include
    source/motors/include/: differential_paired_stepper_motors.h stepper_motor.h
  group source/sensors
    source/sensors/: ir_sensors.cpp simulated_ir_sensors.cpp
  group source/sensors/include
    source/sensors/include/: distance_sensors_interface.h ir_sensors.h simulated_ir_sensors.h
  group source/utility
    source/utility/: frame_of_references.cpp gpio.cpp system_timer.cpp timer_interrupt_oc.cpp
  group source/utility/include
    source/utility/include/: frame_of_references.h gpio.h queue.h system_timer.h timer_interrupt_oc.h util_math.h
  group stm32f4xx
    stm32f4xx/: startup_stm32f4xx.s system_stm32f4xx.c
  group stm32f4xx/include
    stm32f4xx/include/: stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.h
  group stm32f4xx/std_periph_drivers
    stm32f4xx/std_periph_drivers/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c
